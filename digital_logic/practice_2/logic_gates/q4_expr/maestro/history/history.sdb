<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 4 11:54:12 2024</timestamp>
			<uuid>{510ad17a-b226-4bfd-a762-b280bea154d9}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/home/cinovador/Documents/course_files/digital_logic/practice_2/logic_gates/q4_expr/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/cinovador/Documents/course_files/digital_logic/practice_2/logic_gates/q4_expr/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/cinovador/Documents/course_files/digital_logic/practice_2/logic_gates/q4_expr/maestro/logic_gates/q4_expr/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>./logic_gates/q4_expr/maestro/logic_gates/q4_expr/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
