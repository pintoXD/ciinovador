_vvdd! (vdd! 0) vsource dc=1.2 type=dc
