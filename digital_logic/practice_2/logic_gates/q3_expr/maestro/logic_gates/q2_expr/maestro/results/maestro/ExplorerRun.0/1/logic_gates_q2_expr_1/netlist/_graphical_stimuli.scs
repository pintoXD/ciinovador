_vvdd! (vdd! 0) vsource dc=1 type=dc
