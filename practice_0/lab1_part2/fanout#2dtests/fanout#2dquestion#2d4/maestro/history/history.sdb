<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 24 15:49:12 2024</timestamp>
			<uuid>{6ddcba26-3607-49db-8022-71f809cdbaff}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/home/cinovador/Documents/course_files/practice_0/lab1_part2/fanout#2dtests/fanout#2dquestion#2d4/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/cinovador/Documents/course_files/practice_0/lab1_part2/fanout#2dtests/fanout#2dquestion#2d4/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/cinovador/Documents/course_files/practice_0/lab1_part2/fanout-tests-question-2/fanout-tests/fanout-question-4/fanout-tests/fanout-question-4/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>./lab1_part2/fanout-tests-question-2/fanout-tests/fanout-question-4/fanout-tests/fanout-question-4/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
